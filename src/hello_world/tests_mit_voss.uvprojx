# Keil uVision project tests_mit_voss.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tests_mit_voss
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: hello_world.c neigungssensor.c
  group ::CMSIS
    D:/Programme/Keil_v5/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS_RTX/LIB/ARM/: RTX_CM4.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::Device
    RTE/Device/STM32F407VG/: RTE_Device.h startup_stm32f40_41xxx.s system_stm32f4xx.c stm32f4xx_conf.h
    D:/Programme/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.8/RTE_Driver/: GPIO_STM32F4xx.c DMA_STM32F4xx.c
    D:/Programme/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.8/Device/StdPeriph_Driver/src/: stm32f4xx_spi.c misc.c stm32f4xx_rcc.c
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, Device:DMA 1.0.0, Device:GPIO 1.0.1, Device:Startup 1.3.1, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0
